# Keil uVision project ble_app_uarts.uvprojx, settings and files
target IK-52810DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: UHwalker +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74  NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\fds;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\app\ble_uarts;..\..\app\device_name
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74  NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x200022c8 size 0x3d38
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c sensor.c
    ../config/: sdk_config.h
    ../../app/device_name/: device_name_op.c
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_BLE_Services
    ../../app/ble_uarts/: my_ble_uarts.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c nrfx_saadc.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/crc16/: crc16.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
    ../../modules/nrfx/hal/: nrf_nvmc.c
target flash_s112_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: s112_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x19000
  memory RVCT9: RAM 0x200022c8 size 0x3d38
  memory RVCT10: RAM 0x800000 size 0x6000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
